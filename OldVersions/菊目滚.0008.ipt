# Autodesk Inventor part: 앞커버
## iProperties
Company: 한국ATC센터
Created: 2014-08
Part Number: 앞커버
Document SubType Name: Modeling
Designer: KYOUNG IL JANG
Density: 1 g/cm^3
Author: KYOUNG IL JANG
