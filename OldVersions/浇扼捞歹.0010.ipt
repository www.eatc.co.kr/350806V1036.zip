# Autodesk Inventor part: 슬라이더
## iProperties
Company: 한국ATC센터
Created: 2014-08
Part Number: 슬라이더
Document SubType Name: Modeling
Designer: KYOUNG IL JANG
Density: 1 g/cm^3
Author: KYOUNG IL JANG
